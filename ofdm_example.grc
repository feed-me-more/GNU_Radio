options:
  parameters:
    generate_options: qt_gui
    id: ofdm_example
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: isi
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: noisevar
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: s0
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
  states: {}
- name: s1
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
  states: {}
- name: s2
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
  states: {}
- name: s3
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
  states: {}
- name: s4
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
  states: {}
- name: s5
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
  states: {}
- name: s6
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
  states: {}
- name: s7
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noisevar
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '4000'
    repeat: 'True'
    type: int
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: np.diag(1 / np.fft.fft([1, isi, isi**2], 8))
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {}
- name: blocks_multiply_matrix_xx_1
  id: blocks_multiply_matrix_xx
  parameters:
    A: np.diag([s0, s1, s2, s3, s4, s5,s6, s7])
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {bus_sink: true, bus_source: true}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_streams_0
  id: blocks_stream_to_streams
  parameters:
    num_streams: '8'
    type: complex
  states: {}
- name: blocks_stream_to_streams_0_0
  id: blocks_stream_to_streams
  parameters:
    num_streams: '11'
    type: complex
  states: {}
- name: blocks_stream_to_streams_0_1
  id: blocks_stream_to_streams
  parameters:
    num_streams: '8'
    type: complex
  states: {bus_source: true}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '8'
    type: complex
  states: {}
- name: blocks_streams_to_stream_0
  id: blocks_streams_to_stream
  parameters:
    num_streams: '11'
    type: complex
  states: {}
- name: blocks_streams_to_stream_0_0
  id: blocks_streams_to_stream
  parameters:
    num_streams: '8'
    type: complex
  states: {bus_sink: true}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '8'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '8'
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '8'
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: int
    out_type: complex
    symbol_table: '[1+1j,-1+1j,1-1j,-1-1j]'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '8'
    forward: 'False'
    shift: 'False'
    type: complex
    window: '[1]*8'
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '8'
    forward: 'True'
    shift: 'False'
    type: complex
    window: '[1]*8'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: '[1, isi, isi**2]'
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    nconnections: '8'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_stream_to_streams_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_matrix_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_matrix_xx_0, '1', qtgui_const_sink_x_0, '1']
- [blocks_multiply_matrix_xx_0, '2', qtgui_const_sink_x_0, '2']
- [blocks_multiply_matrix_xx_0, '3', qtgui_const_sink_x_0, '3']
- [blocks_multiply_matrix_xx_0, '4', qtgui_const_sink_x_0, '4']
- [blocks_multiply_matrix_xx_0, '5', qtgui_const_sink_x_0, '5']
- [blocks_multiply_matrix_xx_0, '6', qtgui_const_sink_x_0, '6']
- [blocks_multiply_matrix_xx_0, '7', qtgui_const_sink_x_0, '7']
- [blocks_multiply_matrix_xx_1, '8', blocks_streams_to_stream_0_0, '8']
- [blocks_stream_to_streams_0, '0', blocks_streams_to_stream_0, '3']
- [blocks_stream_to_streams_0, '1', blocks_streams_to_stream_0, '4']
- [blocks_stream_to_streams_0, '2', blocks_streams_to_stream_0, '5']
- [blocks_stream_to_streams_0, '3', blocks_streams_to_stream_0, '6']
- [blocks_stream_to_streams_0, '4', blocks_streams_to_stream_0, '7']
- [blocks_stream_to_streams_0, '5', blocks_streams_to_stream_0, '0']
- [blocks_stream_to_streams_0, '5', blocks_streams_to_stream_0, '8']
- [blocks_stream_to_streams_0, '6', blocks_streams_to_stream_0, '1']
- [blocks_stream_to_streams_0, '6', blocks_streams_to_stream_0, '9']
- [blocks_stream_to_streams_0, '7', blocks_streams_to_stream_0, '10']
- [blocks_stream_to_streams_0, '7', blocks_streams_to_stream_0, '2']
- [blocks_stream_to_streams_0_0, '0', blocks_null_sink_0, '0']
- [blocks_stream_to_streams_0_0, '1', blocks_null_sink_0_0, '0']
- [blocks_stream_to_streams_0_0, '10', blocks_streams_to_vector_0, '7']
- [blocks_stream_to_streams_0_0, '2', blocks_null_sink_0_1, '0']
- [blocks_stream_to_streams_0_0, '3', blocks_streams_to_vector_0, '0']
- [blocks_stream_to_streams_0_0, '4', blocks_streams_to_vector_0, '1']
- [blocks_stream_to_streams_0_0, '5', blocks_streams_to_vector_0, '2']
- [blocks_stream_to_streams_0_0, '6', blocks_streams_to_vector_0, '3']
- [blocks_stream_to_streams_0_0, '7', blocks_streams_to_vector_0, '4']
- [blocks_stream_to_streams_0_0, '8', blocks_streams_to_vector_0, '5']
- [blocks_stream_to_streams_0_0, '9', blocks_streams_to_vector_0, '6']
- [blocks_stream_to_streams_0_1, '8', blocks_multiply_matrix_xx_1, '8']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_streams_to_stream_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_streams_to_stream_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_streams_to_vector_0, '0', fft_vxx_0_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_streams_0_1, '0']
- [blocks_vector_to_stream_0, '0', blocks_stream_to_streams_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_multiply_matrix_xx_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_multiply_matrix_xx_0, '1']
- [blocks_vector_to_streams_0, '2', blocks_multiply_matrix_xx_0, '2']
- [blocks_vector_to_streams_0, '3', blocks_multiply_matrix_xx_0, '3']
- [blocks_vector_to_streams_0, '4', blocks_multiply_matrix_xx_0, '4']
- [blocks_vector_to_streams_0, '5', blocks_multiply_matrix_xx_0, '5']
- [blocks_vector_to_streams_0, '6', blocks_multiply_matrix_xx_0, '6']
- [blocks_vector_to_streams_0, '7', blocks_multiply_matrix_xx_0, '7']
- [digital_chunks_to_symbols_xx_0, '0', blocks_throttle2_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_streams_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
